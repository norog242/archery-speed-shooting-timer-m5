#pragma once

const char* TRANSLATIONS_JS = R"rawliteral(
const translations = {
  EN: {
    // Main page
    arrowCount: 'Arrow Count:',
    time: 'Time:',
    score: 'Score:',
    points: 'Points:',
    reset: 'Reset',
    start: 'Start',
    saveTournamentResult: 'Save Tournament result (ID:',
    selectArcher: '-- Select Archer --',
    save: 'Save',
    lastAttempts: 'Last 5 Attempts',
    deviceSettings: 'Device Settings',
    wifiSettings: 'WiFi Settings',
    tournamentSettings: 'Tournament Settings',
    updates: 'Updates every 0.5 seconds',
    pleaseSelect: 'Please select an archer',
    pleaseComplete: 'Please complete',
    arrowsBefore: 'arrows before saving to tournament',
    invalidDuration: 'Invalid duration',
    saving: 'Saving...',
    savedSuccessfully: 'Result saved successfully for',
    errorMsg: 'Error:',
    
    // Device Settings page
    title: 'Device Settings',
    currentSettings: 'Current Settings:',
    numArrows: 'Number of Arrows:',
    sensitivityThreshold: 'Sensitivity Threshold:',
    language: 'Language:',
    configureSettings: 'Configure Timer Settings',
    numArrowsLabel: 'Number of Arrows:',
    numArrowsInfo: 'Set how many arrows to count before stopping the timer (default: 10)',
    sensitivityLabel: 'Sensitivity Threshold:',
    sensitivityInfo: 'Adjust the acceleration threshold for detecting arrow impacts (1010-1500 milli-g, default: 1200)',
    lowerValues: 'Lower values',
    moreSensitive: 'more sensitive (may detect false positives)',
    higherValues: 'Higher values',
    lessSensitive: 'less sensitive (may miss softer impacts)',
    languageLabel: 'Language:',
    languageInfo: 'Select interface language',
    resetDefaults: 'Reset to Defaults',
    backToTimer: 'Back to Timer',
    noteTitle: 'Note:',
    noteText: 'These settings control the basic operation of the arrow timer device. The number of arrows determines when the timer stops counting, and the sensitivity threshold controls how strong an impact must be to register as an arrow hit.',
    noteText2: 'All settings are stored persistently and will be retained after device restart or power loss.',
    tipTitle: 'Tip:',
    tipText: 'If the timer is too sensitive (counting accidental bumps) or not sensitive enough (missing arrow impacts), adjust the sensitivity threshold. Start with small adjustments of ±50-100 milli-g.',
    validArrows: 'Please enter a valid number of arrows (minimum 1)',
    savedSuccess: 'Device settings saved successfully!',
    errorSaving: 'Error saving device settings:',
    resetConfirm: 'Are you sure you want to reset to default settings? (10 arrows, 1200 milli-g sensitivity, English language)',
    resetMessage: 'Settings reset to defaults. Click Save to apply.',
    error: 'Error',
    loading: 'Loading...',
    
    // WiFi Settings page
    wifiConfigTitle: 'WiFi Configuration',
    currentStatus: 'Current Status:',
    mode: 'Mode:',
    network: 'Network:',
    ipAddress: 'IP Address:',
    hostname: 'Hostname:',
    connectToWifi: 'Connect to WiFi Network',
    wifiNetworkName: 'WiFi Network Name (SSID):',
    enterWifiSSID: 'Enter WiFi SSID',
    enterNetworkName: 'Enter the name of your WiFi network',
    wifiPassword: 'WiFi Password:',
    enterWifiPassword: 'Enter WiFi password',
    leaveEmptyOpen: 'Leave empty for open networks',
    saveRestart: 'Save & Restart',
    clearConfiguration: 'Clear Configuration',
    connectedToWifi: 'Connected to WiFi',
    accessPointMode: 'Access Point Mode',
    pleaseEnterSSID: 'Please enter a WiFi SSID',
    configSaved: 'Configuration saved! Device will restart and connect to the new WiFi network. You may need to reconnect to the new network.',
    errorSavingConfig: 'Error saving configuration:',
    clearWifiConfirm: 'Are you sure you want to clear the WiFi configuration? Device will restart in Access Point mode.',
    wifiConfigCleared: 'WiFi configuration cleared! Device will restart in Access Point mode.',
    errorClearingConfig: 'Error clearing configuration:',
    wifiNoteText: 'After saving, the device will restart and attempt to connect to the specified WiFi network. If connection fails, it will automatically fall back to Access Point mode (ArrowTimerAP). The configuration is stored persistently and will be used after power loss.',
    easyAccessTitle: 'Easy Access:',
    easyAccessText: 'When connected to WiFi, access the device at',
    mdnsNote: '(works on most devices with mDNS/Bonjour support). The IP address and hostname are also displayed on the device screen.',
    hardwareResetTitle: 'Hardware Reset:',
    hardwareResetText: 'To reset WiFi credentials without web access, press and hold the device button for 10 seconds. The device will show a countdown and then restart in Access Point mode.',
    
    // Tournament Settings page
    tournamentConfigTitle: 'Tournament Configuration',
    notConfigured: 'Not configured',
    tournamentId: 'Tournament ID',
    domain: 'Domain',
    tournamentIntegration: 'Tournament Integration',
    apiDomain: 'API Domain:',
    enterApiDomain: 'Enter the domain of your tournament API (without https://)',
    tournamentIdLabel: 'Tournament ID:',
    enterTournamentId: 'Enter tournament ID',
    enterNumericId: 'Enter the numeric ID of your tournament',
    clearTournamentConfig: 'Clear Tournament Config',
    participants: 'Participants',
    loadingParticipants: 'Loading participants...',
    noParticipantsFound: 'No participants found',
    refreshParticipants: 'Refresh Participants',
    pleaseEnterTournamentId: 'Please enter a tournament ID',
    pleaseEnterApiDomain: 'Please enter an API domain',
    tournamentConfigSaved: 'Tournament configuration saved successfully!',
    errorSavingTournament: 'Error saving tournament configuration:',
    clearTournamentConfirm: 'Are you sure you want to clear the tournament configuration?',
    tournamentConfigCleared: 'Tournament configuration cleared successfully!',
    errorClearingTournament: 'Error clearing tournament configuration:',
    tournamentNoteText: 'Configure the API domain and tournament ID to integrate this timer with your tournament management application. The API domain should point to your tournament system (e.g., archers.himmelix.ch or a test environment). Enter the numeric ID provided by your tournament system to link this device with your tournament.',
    tournamentNoteText2: 'The configuration is stored persistently and will be retained after device restart or power loss.',
    errorLoadingStatus: 'Error loading status',
    failedToLoadParticipants: 'Failed to load participants'
  },
  DE: {
    // Main page
    arrowCount: 'Pfeilanzahl:',
    time: 'Zeit:',
    score: 'Punkte/s:',
    points: 'Punkte:',
    reset: 'Reset',
    start: 'Start',
    saveTournamentResult: 'Turnierergebnis speichern (ID:',
    selectArcher: '-- Schütze auswählen --',
    save: 'Speichern',
    lastAttempts: 'Letzte 5 Versuche',
    deviceSettings: 'Geräteeinstellungen',
    wifiSettings: 'WLAN-Einstellungen',
    tournamentSettings: 'Turniereinstellungen',
    updates: 'Aktualisierung alle 0.5 Sekunden',
    pleaseSelect: 'Bitte wählen Sie einen Schützen',
    pleaseComplete: 'Bitte absolvieren Sie',
    arrowsBefore: 'Pfeile vor dem Speichern im Turnier',
    invalidDuration: 'Ungültige Dauer',
    saving: 'Speichert...',
    savedSuccessfully: 'Ergebnis erfolgreich gespeichert für',
    errorMsg: 'Fehler:',
    
    // Device Settings page
    title: 'Geräteeinstellungen',
    currentSettings: 'Aktuelle Einstellungen:',
    numArrows: 'Anzahl Pfeile:',
    sensitivityThreshold: 'Empfindlichkeitsschwelle:',
    language: 'Sprache:',
    configureSettings: 'Timer-Einstellungen konfigurieren',
    numArrowsLabel: 'Anzahl Pfeile:',
    numArrowsInfo: 'Legen Sie fest, wie viele Pfeile gezählt werden sollen, bevor der Timer stoppt (Standard: 10)',
    sensitivityLabel: 'Empfindlichkeitsschwelle:',
    sensitivityInfo: 'Passen Sie die Beschleunigungsschwelle für die Erkennung von Pfeileinschlägen an (1010-1500 milli-g, Standard: 1200)',
    lowerValues: 'Niedrigere Werte',
    moreSensitive: 'empfindlicher (kann Fehlalarme erkennen)',
    higherValues: 'Höhere Werte',
    lessSensitive: 'weniger empfindlich (kann weiche Einschläge verpassen)',
    languageLabel: 'Sprache:',
    languageInfo: 'Sprache der Benutzeroberfläche auswählen',
    resetDefaults: 'Standardwerte',
    backToTimer: 'Zurück zum Timer',
    noteTitle: 'Hinweis:',
    noteText: 'Diese Einstellungen steuern den Basisbetrieb des Pfeil-Timer-Geräts. Die Anzahl der Pfeile bestimmt, wann der Timer stoppt, und die Empfindlichkeitsschwelle bestimmt, wie stark ein Einschlag sein muss, um als Pfeiltreffer erkannt zu werden.',
    noteText2: 'Alle Einstellungen werden dauerhaft gespeichert und bleiben nach einem Neustart oder Stromausfall erhalten.',
    tipTitle: 'Tipp:',
    tipText: 'Wenn der Timer zu empfindlich ist (zählt versehentliche Stöße) oder nicht empfindlich genug ist (verpasst Pfeileinschläge), passen Sie die Empfindlichkeitsschwelle an. Beginnen Sie mit kleinen Anpassungen von ±50-100 milli-g.',
    validArrows: 'Bitte geben Sie eine gültige Anzahl von Pfeilen ein (mindestens 1)',
    savedSuccess: 'Geräteeinstellungen erfolgreich gespeichert!',
    errorSaving: 'Fehler beim Speichern der Geräteeinstellungen:',
    resetConfirm: 'Möchten Sie wirklich auf die Standardeinstellungen zurücksetzen? (10 Pfeile, 1200 milli-g Empfindlichkeit, Englische Sprache)',
    resetMessage: 'Einstellungen auf Standardwerte zurückgesetzt. Klicken Sie auf Speichern, um anzuwenden.',
    error: 'Fehler',
    loading: 'Wird geladen...',
    
    // WiFi Settings page
    wifiConfigTitle: 'WLAN-Konfiguration',
    currentStatus: 'Aktueller Status:',
    mode: 'Modus:',
    network: 'Netzwerk:',
    ipAddress: 'IP-Adresse:',
    hostname: 'Hostname:',
    connectToWifi: 'Mit WLAN-Netzwerk verbinden',
    wifiNetworkName: 'WLAN-Netzwerkname (SSID):',
    enterWifiSSID: 'WLAN-SSID eingeben',
    enterNetworkName: 'Geben Sie den Namen Ihres WLAN-Netzwerks ein',
    wifiPassword: 'WLAN-Passwort:',
    enterWifiPassword: 'WLAN-Passwort eingeben',
    leaveEmptyOpen: 'Leer lassen für offene Netzwerke',
    saveRestart: 'Speichern & Neu starten',
    clearConfiguration: 'Konfiguration löschen',
    connectedToWifi: 'Mit WLAN verbunden',
    accessPointMode: 'Access-Point-Modus',
    pleaseEnterSSID: 'Bitte geben Sie eine WLAN-SSID ein',
    configSaved: 'Konfiguration gespeichert! Das Gerät wird neu gestartet und versucht, sich mit dem neuen WLAN-Netzwerk zu verbinden. Möglicherweise müssen Sie sich mit dem neuen Netzwerk verbinden.',
    errorSavingConfig: 'Fehler beim Speichern der Konfiguration:',
    clearWifiConfirm: 'Möchten Sie wirklich die WLAN-Konfiguration löschen? Das Gerät wird im Access-Point-Modus neu gestartet.',
    wifiConfigCleared: 'WLAN-Konfiguration gelöscht! Das Gerät wird im Access-Point-Modus neu gestartet.',
    errorClearingConfig: 'Fehler beim Löschen der Konfiguration:',
    wifiNoteText: 'Nach dem Speichern wird das Gerät neu gestartet und versucht, sich mit dem angegebenen WLAN-Netzwerk zu verbinden. Wenn die Verbindung fehlschlägt, wechselt es automatisch in den Access-Point-Modus (ArrowTimerAP). Die Konfiguration wird dauerhaft gespeichert und nach einem Stromausfall wiederverwendet.',
    easyAccessTitle: 'Einfacher Zugriff:',
    easyAccessText: 'Wenn das Gerät mit WLAN verbunden ist, greifen Sie unter',
    mdnsNote: 'auf das Gerät zu (funktioniert auf den meisten Geräten mit mDNS/Bonjour-Unterstützung). Die IP-Adresse und der Hostname werden auch auf dem Gerätebildschirm angezeigt.',
    hardwareResetTitle: 'Hardware-Reset:',
    hardwareResetText: 'Um WLAN-Anmeldedaten ohne Webzugriff zurückzusetzen, halten Sie die Gerätetaste 10 Sekunden lang gedrückt. Das Gerät zeigt einen Countdown an und startet dann im Access-Point-Modus neu.',
    
    // Tournament Settings page
    tournamentConfigTitle: 'Turnierkonfiguration',
    notConfigured: 'Nicht konfiguriert',
    tournamentId: 'Turnier-ID',
    domain: 'Domain',
    tournamentIntegration: 'Turnierintegration',
    apiDomain: 'API-Domain:',
    enterApiDomain: 'Geben Sie die Domain Ihrer Turnier-API ein (ohne https://)',
    tournamentIdLabel: 'Turnier-ID:',
    enterTournamentId: 'Turnier-ID eingeben',
    enterNumericId: 'Geben Sie die numerische ID Ihres Turniers ein',
    clearTournamentConfig: 'Turnierkonfiguration löschen',
    participants: 'Teilnehmer',
    loadingParticipants: 'Teilnehmer werden geladen...',
    noParticipantsFound: 'Keine Teilnehmer gefunden',
    refreshParticipants: 'Teilnehmer aktualisieren',
    pleaseEnterTournamentId: 'Bitte geben Sie eine Turnier-ID ein',
    pleaseEnterApiDomain: 'Bitte geben Sie eine API-Domain ein',
    tournamentConfigSaved: 'Turnierkonfiguration erfolgreich gespeichert!',
    errorSavingTournament: 'Fehler beim Speichern der Turnierkonfiguration:',
    clearTournamentConfirm: 'Möchten Sie wirklich die Turnierkonfiguration löschen?',
    tournamentConfigCleared: 'Turnierkonfiguration erfolgreich gelöscht!',
    errorClearingTournament: 'Fehler beim Löschen der Turnierkonfiguration:',
    tournamentNoteText: 'Konfigurieren Sie die API-Domain und Turnier-ID, um diesen Timer in Ihre Turnierverwaltungsanwendung zu integrieren. Die API-Domain sollte auf Ihr Turniersystem verweisen (z. B. archers.himmelix.ch oder eine Testumgebung). Geben Sie die numerische ID ein, die von Ihrem Turniersystem bereitgestellt wird, um dieses Gerät mit Ihrem Turnier zu verknüpfen.',
    tournamentNoteText2: 'Die Konfiguration wird dauerhaft gespeichert und bleibt nach einem Neustart oder Stromausfall erhalten.',
    errorLoadingStatus: 'Fehler beim Laden des Status',
    failedToLoadParticipants: 'Fehler beim Laden der Teilnehmer'
  }
};

function applyTranslations() {
  const t = translations[window.currentLang || 'EN'];
  document.querySelectorAll('[data-i18n]').forEach(el => {
    const key = el.getAttribute('data-i18n');
    if (t[key]) {
      if (el.tagName === 'INPUT' && el.type === 'submit') {
        el.value = t[key];
      } else {
        el.textContent = t[key];
      }
    }
  });
  
  // Handle placeholder translations
  document.querySelectorAll('[data-i18n-placeholder]').forEach(el => {
    const key = el.getAttribute('data-i18n-placeholder');
    if (t[key]) {
      el.placeholder = t[key];
    }
  });
}
)rawliteral";
